# Keil uVision project EVB_DirDetect_Keil.uvproj, settings and files
target F072_Debug (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: N572F072 Nuvoton
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0x11FFF) CLOCK(48000000) CPUTYPE("Cortex-M0")
  output: EVB_DirDetectD_Keil
  AfterMake: fromelf --i32combined --output F072\Debug\EVB_DirDetectD_Keil.hex F072\Debug\EVB_DirDetectD_Keil.axf
  AfterMake: ../Nuvoton/WindowsPlatform/Tool/Utility/hex2bin F072\Debug\EVB_DirDetectD_Keil.hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: __N572F072__ __CORTEX_M0 __CMSIS_RTOS
  c include: .;../Shared/Nuvoton;../Nuvoton/HW/Include;../Nuvoton/Include;../RTX/INC;../RTX/SRC
  asm define: __N572F072__
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\EVB_DirDetect_F072_Keil.ld
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler --remove --userlibpath="../Nuvoton/Lib" SDK_F072_Keil.lib Driver_F072_keil.lib
  group CMSIS
    ../Nuvoton/CMSIS/CM0/: core_cm0.c
    ../Nuvoton/CMSIS/CM0/startup/arm/: startup_N572_Keil.s
  group Header Files
    ./: Global.h Debug.h SysClkConfig.h Idle.h DirDetect.h
    ../Shared/Nuvoton/: XPrintf.h Spi.h Packet.h
  group Source Files
    ../Nuvoton/HW/Include/: SFR.c
    ./: Main.c Idle.c Spi.c DirDetect.c
    ../Shared/Nuvoton/: XPrintf.c
  group Lib Files
    ../Nuvoton/Lib/Commu/: SemiHost_Keil.lib
  group Documentation
    ./: Abstract.txt
target F072_Release (ARM-ADS)
  device: N572F072 Nuvoton
  cpu: as above
  output: EVB_DirDetect_Keil
  AfterMake: fromelf --i32combined --output F072\Release\EVB_DirDetect_Keil.hex F072\Release\EVB_DirDetect_Keil.axf
  AfterMake: ../../../../WindowsPlatform/Tool/Utility/hex2bin F072\Release\EVB_DirDetect_Keil.hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c define: __N572F072__ __CORTEX_M0 __CMSIS_RTOS
  c include: as above
  asm define: __N572F072__
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\EVB_DirDetect_F072_Keil.ld
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler --remove --userlibpath="../../../lib" Driver_F072_keil.lib
